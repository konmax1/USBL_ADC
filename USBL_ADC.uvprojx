# Keil uVision project USBL_ADC.uvprojx, settings and files
target Target 1 (6090000::V6.9::.\ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: USBL_ADC
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: ARM_MATH_CM7,__DSP_PRESENT
  c include: .\header
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Source Group 1
    ./RTE/Device/STM32H743ZITx/STCubeGenerated/Src/: stm32h7xx_hal_timebase_TIM.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743ZITx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743ZITx/STCubeGenerated/Inc/: stm32h7xx_it.h
  group Logic
    ./src/: ramFunc.cpp Thread.cpp MultiFifo.cpp
    ./header/: MultiFifo.h Thread.h
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, CMSIS:RTOS2:Keil RTX5 5.3.0, Compiler:I/O:STDOUT 1.4.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:DMA 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:MDMA 1.2.0, Device:STM32Cube HAL:NAND 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:QSPI 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:STM32Cube HAL:TIM 1.2.0, Device:STM32Cube HAL:UART 1.2.0, Device:Startup 1.2.0
